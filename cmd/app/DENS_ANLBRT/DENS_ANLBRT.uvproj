# Keil uVision project DENS_ANLBRT.uvproj, settings and files
target DENS_ANLBRT (MCS-51)
  device: EZ-USB FX1 (CY7C647XX) Cypress Semiconductor
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) CLOCK(48000000) MODDP2
  output: DENS_ANLBRT +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\inc\
  group Исходный код
    ./: periph.c AnlBrt.c
  group FrameWork
    ./: fw.c dscr.a51
    ../Lib/LP/: EZUSB.LIB USBJmpTb.OBJ
  group Include
    ./: AnlBrt.h
